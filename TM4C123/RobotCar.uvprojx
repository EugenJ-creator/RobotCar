# Keil uVision project RobotCar.uvprojx, settings and files
target Target (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IROM(0x00000000,0x040000) IRAM(0x20000000,0x008000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RobotCar
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c misc: --C99
  c include: ../inc
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Source code
    ../inc/: BSP.c Profile.c
    ./: osasm.s os.c RobotCar.c Math.c Math.h PLL.c RobotCar.h pid_ctrl.c pid_ctrl.h
  group Object code
    ./: texas.o
  group MotorDriver
    ./: ServoTD8120MG.c ServoTD8120MG.h DCMotor.c DCMotor.h
  group Bluetooth
    ./: AP_Services.c AP.c AP_Mail.c
  group Hardware
    ../inc/: UART0.c UART1.c CortexM.c
    ./: PWM.c I2C3.c I2C3.h I2C1.c I2C1.h ADCT0.c ADCT0.h GPIO_DIF.c
  group ActorDriver
    ./: Buzzer.c Buzzer.h TempHumidity.c TempHumidity.h GyroAccelMag.c GyroAccelMag.h LightSensoe.c LightSensor.h
  group CAN
    ./: CanTransmitReceive.c
    ../driverlib/: can.c gpio.c interrupt.c sysctl.c uart.c cpu.c
    ../utils/: uartstdio.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
